# Keil uVision project Nokia6151.uvprojx, settings and files
target Nokia6151 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Nokia6151
  c flags: Optim=4 OneElfS=1
  c include: .\inc;..\..\libs\lib_STM32F10x_StdPeriph\inc;..\..\libs\lib_SPFD54124B\inc;..\..\libs\lib_delay\inc;..\..\libs\lib_BSP_HY-STM32\inc;..\..\libs\lib_tjpegd\inc;..\..\libs\lib_xorshift\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ./startup/: system_stm32f10x.c startup_stm32f10x_hd.s
  group inc
    ./inc/: jpeg.h adc.h explosion.h
  group src
    ./src/: main.c stm32xxx_it.c pictures.s jpeg.c adc.c explosion.c
  group lib
    ../../libs/lib_STM32F10x_StdPeriph/obj/: lib_STM32F10x_StdPeriph.lib
    ../../libs/lib_delay/obj/: lib_delay.lib
    ../../libs/lib_BSP_HY-STM32/obj/: lib_BSP_HY-STM32.lib
    ../../libs/lib_tjpegd/obj/: lib_tjpegd.lib
    ../../libs/lib_SPFD54124B/obj/: lib_SPFD54124B.lib
    ../../libs/lib_xorshift/obj/: lib_xorshift.lib
  group pictures
    ./Pictures/: 1.jpg 2.jpg 3.jpg 4.jpg 5.jpg
