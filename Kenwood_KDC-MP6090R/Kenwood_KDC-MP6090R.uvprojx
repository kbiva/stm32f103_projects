# Keil uVision project Kenwood_KDC-MP6090R.uvprojx, settings and files
target Kenwood_KDC-MP6090R (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: Kenwood_KDC-MP6090R
  c flags: Optim=4 OneElfS=1
  c include: .\inc;..\..\libs\lib_STM32F10x_StdPeriph\inc;..\..\libs\lib_delay\inc;..\..\libs\lib_BSP_HY-STM32\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group inc
    ./inc/: font.h mp6090r.h ir_decode.h nec_decode.h queue.h
  group src
    ./src/: main.c mp6090r.c ir_decode.c queue.c
  group lib
    ../../libs/lib_STM32F10x_StdPeriph/obj/: lib_STM32F10x_StdPeriph.lib
    ../../libs/lib_delay/obj/: lib_delay.lib
    ../../libs/lib_BSP_HY-STM32/obj/: lib_BSP_HY-STM32.lib
  group startup
    ./startup/: system_stm32f10x.c startup_stm32f10x_hd.s
