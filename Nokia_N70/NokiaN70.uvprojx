# Keil uVision project NokiaN70.uvprojx, settings and files
target NokiaN70 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: NokiaN70
  c flags: Optim=4 OneElfS=1
  c include: .\inc;..\..\libs\lib_STM32F10x_StdPeriph\inc;..\..\libs\lib_MC2PA8201\inc;..\..\libs\lib_delay\inc;..\..\libs\lib_BSP_HY-STM32\inc;..\..\libs\lib_tjpegd\inc;..\..\libs\lib_xorshift\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ./startup/: system_stm32f10x.c startup_stm32f10x_hd.s
  group inc
    ./inc/: jpeg.h
  group src
    ./src/: main.c stm32xxx_it.c pictures.s jpeg.c
  group lib
    ../../libs/lib_STM32F10x_StdPeriph/obj/: lib_STM32F10x_StdPeriph.lib
    ../../libs/lib_delay/obj/: lib_delay.lib
    ../../libs/lib_BSP_HY-STM32/obj/: lib_BSP_HY-STM32.lib
    ../../libs/lib_tjpegd/obj/: lib_tjpegd.lib
    ../../libs/lib_xorshift/obj/: lib_xorshift.lib
    ../../libs/lib_MC2PA8201/obj/: lib_MC2PA8201.lib
