# Keil uVision project Samsung_E700.uvprojx, settings and files
target Samsung_E700 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Samsung_E700
  c flags: Optim=4 OneElfS=1
  c include: .\inc;..\..\libs\lib_STM32F10x_StdPeriph\inc;..\..\libs\lib_delay\inc;..\..\libs\lib_BSP_HY-STM32\inc;..\..\libs\lib_HD66773R\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group inc
    ./inc/: 3d.h
  group src
    ./src/: main.c stm32xxx_it.c 3d.c
  group lib
    ../../libs/lib_STM32F10x_StdPeriph/obj/: lib_STM32F10x_StdPeriph.lib
    ../../libs/lib_delay/obj/: lib_delay.lib
    ../../libs/lib_BSP_HY-STM32/obj/: lib_BSP_HY-STM32.lib
    ../../libs/lib_HD66773R/Objects/: lib_HD66773R.lib
  group startup
    ./startup/: system_stm32f10x.c startup_stm32f10x_hd.s
