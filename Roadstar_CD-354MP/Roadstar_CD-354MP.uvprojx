# Keil uVision project Roadstar_CD-354MP.uvprojx, settings and files
target Roadstar_CD-354MP (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: Roadstar_CD-354MP
  c flags: Optim=4 OneElfS=1
  c include: .\inc;..\..\libs\lib_STM32F10x_StdPeriph\inc;..\..\libs\lib_delay\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group inc
    ./inc/: adc.h cd354mp.h font.h
  group src
    ./src/: adc.c cd354mp.c main.c stm32xxx_it.c
  group lib
    ../../libs/lib_STM32F10x_StdPeriph/obj/: lib_STM32F10x_StdPeriph.lib
    ../../libs/lib_delay/obj/: lib_delay.lib
  group startup
    ./startup/: system_stm32f10x.c startup_stm32f10x_hd.s
