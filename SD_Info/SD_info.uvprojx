# Keil uVision project SD_info.uvprojx, settings and files
target SD_info (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: SD_info
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c include: .\inc;..\..\libs\lib_STM32F10x_StdPeriph\inc;..\..\libs\lib_delay\inc;..\..\libs\lib_LGDP4532\inc;..\..\libs\lib_SD_SDIO\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group src
    ./src/: main.c stm32xxx_it.c
  group lib
    ../../libs/lib_STM32F10x_StdPeriph/obj/: lib_STM32F10x_StdPeriph.lib
    ../../libs/lib_LGDP4532/obj/: lib_LGDP4532.lib
    ../../libs/lib_SD_SDIO/obj/: lib_SD_SDIO.lib
    ../../libs/lib_delay/obj/: lib_delay.lib
  group startup
    ./startup/: system_stm32f10x.c startup_stm32f10x_hd.s
