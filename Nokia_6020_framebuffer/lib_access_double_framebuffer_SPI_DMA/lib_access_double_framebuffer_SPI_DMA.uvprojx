# Keil uVision project lib_access_double_framebuffer_SPI_DMA.uvprojx, settings and files
target lib_access_double_framebuffer_SPI_DMA (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: lib_access_double_framebuffer_SPI_DMA (library)
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\Nokia_6020_framebuffer\inc;..\..\..\libs\lib_STM32F10x_StdPeriph\inc;..\..\..\libs\lib_PCF8833\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group src
    ./src/: access_double_framebuffer_SPI_DMA.c
