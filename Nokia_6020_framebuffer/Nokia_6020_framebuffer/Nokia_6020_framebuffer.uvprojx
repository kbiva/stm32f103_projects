# Keil uVision project Nokia_6020_framebuffer.uvprojx, settings and files
target Nokia_6020_framebuffer (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: Nokia_6020_framebuffer
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1
  c include: .\inc;..\..\..\libs\lib_STM32F10x_StdPeriph\inc;..\..\..\libs\lib_PCF8833\inc;..\..\..\libs\lib_BSP_HY-STM32\inc;..\..\..\libs\lib_delay\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ./startup/: system_stm32f10x.c startup_stm32f10x_hd.s
  group inc
    ./inc/: rotating_cube_checkboard.h
  group src
    ./src/: main.c rotating_cube_checkboard.c stm32xxx_it.c
  group libs
    ../../../libs/lib_STM32F10x_StdPeriph/obj/: lib_STM32F10x_StdPeriph.lib
    ../../../libs/lib_BSP_HY-STM32/obj/: lib_BSP_HY-STM32.lib
    ../../../libs/lib_delay/obj/: lib_delay.lib
    ../../../libs/lib_PCF8833/obj/: lib_PCF8833.lib
    ../lib_access_pixel_BB/obj/: lib_access_pixel_BB.lib
    ../lib_access_pixel_SPI/obj/: lib_access_pixel_SPI.lib
    ../lib_access_framebuffer_BB/obj/: lib_access_framebuffer_BB.lib
    ../lib_access_framebuffer_SPI/obj/: lib_access_framebuffer_SPI.lib
    ../lib_access_framebuffer_SPI_DMA/obj/: lib_access_framebuffer_SPI_DMA.lib
    ../lib_access_double_framebuffer_SPI_DMA/obj/: lib_access_double_framebuffer_SPI_DMA.lib
