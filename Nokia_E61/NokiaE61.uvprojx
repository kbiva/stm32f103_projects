# Keil uVision project NokiaE61.uvprojx, settings and files
target NokiaE61 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: NokiaE61
  c flags: Optim=4 OneElfS=1
  c include: .\inc;..\..\libs\lib_STM32F10x_StdPeriph\inc;..\..\libs\lib_MC2PA8201\inc;..\..\libs\lib_delay\inc;..\..\libs\lib_BSP_HY-STM32\inc;..\..\libs\lib_tjpegd\inc;..\..\libs\lib_xorshift\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ./startup/: system_stm32f10x.c startup_stm32f10x_hd.s
  group inc
    ./inc/: 3d.h jpeg.h
  group src
    ./src/: 3d.c main.c stm32xxx_it.c jpeg.c pictures.s
  group Pictures
    ./Pictures/: 1.jpg 2.jpg 3.jpg 4.jpg 5.jpg 6.jpg 7.jpg 8.jpg 9.jpg 10.jpg 11.jpg 12.jpg 13.jpg 14.jpg 15.jpg 16.jpg 17.jpg 18.jpg 28.jpg Photo3.jpg
  group lib
    ../../libs/lib_STM32F10x_StdPeriph/obj/: lib_STM32F10x_StdPeriph.lib
    ../../libs/lib_MC2PA8201/obj/: lib_MC2PA8201.lib
    ../../libs/lib_delay/obj/: lib_delay.lib
    ../../libs/lib_BSP_HY-STM32/obj/: lib_BSP_HY-STM32.lib
    ../../libs/lib_tjpegd/obj/: lib_tjpegd.lib
    ../../libs/lib_xorshift/obj/: lib_xorshift.lib
