# Keil uVision project Sony_Ericsson_K800i.uvprojx, settings and files
target Sony_Ericsson_K800i (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Sony_Ericsson_K800i
  c flags: Optim=4 OneElfS=1
  c include: .\inc;..\..\libs\lib_STM32F10x_StdPeriph\inc;..\..\libs\lib_R63400\inc;..\..\libs\lib_delay\inc;..\..\libs\lib_BSP_HY-STM32\inc;..\..\libs\lib_tjpegd\inc;..\..\libs\lib_xorshift\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ./startup/: system_stm32f10x.c startup_stm32f10x_hd.s
  group inc
    ./inc/: 3d.h jpeg.h adc.h bouncingballs.h
  group src
    ./src/: 3d.c main.c stm32xxx_it.c jpeg.c pictures.s adc.c bouncingballs.c
  group Pictures
    ./Pictures/: Cherry.jpg City.jpg Feather.jpg Icelight.jpg Jellicious.jpg Light.jpg Mystic.jpg Shimmering.jpg Sparkly.jpg
  group lib
    ../../libs/lib_STM32F10x_StdPeriph/obj/: lib_STM32F10x_StdPeriph.lib
    ../../libs/lib_delay/obj/: lib_delay.lib
    ../../libs/lib_BSP_HY-STM32/obj/: lib_BSP_HY-STM32.lib
    ../../libs/lib_tjpegd/obj/: lib_tjpegd.lib
    ../../libs/lib_xorshift/obj/: lib_xorshift.lib
    ../../libs/lib_R63400/obj/: lib_R63400.lib
